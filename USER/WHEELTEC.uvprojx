# Keil uVision project WHEELTEC.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WHEELTEC +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\ADC;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\OLED;..\HARDWARE\PS2;..\HARDWARE\USARTX;..\BALANCE\SYSTEM;..\BALANCE\DMP;..\BALANCE\MPU6050;..\BALANCE\show;..\BALANCE\BALANCE;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\DataScope_DP;..\BALANCE\Robot_Select_Init;..\HARDWARE\CAN;..\HARDWARE\HUB_DRIVER;..\BALANCE\DMP;..\HARDWARE\STMFLASH;..\BALANCE\filter
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/HUB_DRIVER/: HubDriver.c HubDriverCan.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Balance
    ../BALANCE/SYSTEM/: system.c
    ../BALANCE/show/: show.c
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/BALANCE/: balance.c
    ../BALANCE/Robot_Select_Init/: robot_select_init.c
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
